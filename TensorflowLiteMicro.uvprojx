# Keil uVision project TensorflowLiteMicro.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: ARMv8MML ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") TZ CLOCK(12000000) ESEL ELITTLE
  output: TensorflowLiteMicro (library)
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=1
  c define: CMSIS_NN TF_LITE_STRIP_ERROR_STRINGS
  c include: .\Packages\tflite_micro\tensorflow\lite\micro\tools\make\downloads\flatbuffers\include;.\Packages\tflite_micro\tensorflow\lite\micro\tools\make\downloads\gemmlowp;.\Packages\tflite_micro\tensorflow\lite\micro\tools\make\downloads\kissfft;.\Packages\tflite_micro\tensorflow\lite\micro\tools\make\downloads\ruy;.\Packages\tflite_micro\tensorflow\lite\micro\tools\cmsis\CMSIS\DSP\Include;.\Packages\tflite_micro\tensorflow\lite\micro\tools\cmsis\CMSIS\NN\Include;.\Packages\tflite_micro\tensorflow\lite\micro\tools\cmsis\CMSIS\NN;.\Packages\tflite_micro
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group CMSIS/NN
    ./Packages/tflite_micro/tensorflow/lite/micro/tools/cmsis/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q7.c arm_nn_activations_q15.c arm_relu_q7.c arm_relu_q15.c arm_relu6_s8.c
    ./Packages/tflite_micro/tensorflow/lite/micro/tools/cmsis/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_add_s8.c arm_elementwise_add_s16.c arm_elementwise_mul_s8.c arm_elementwise_mul_s16.c
    ./Packages/tflite_micro/tensorflow/lite/micro/tools/cmsis/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
    ./Packages/tflite_micro/tensorflow/lite/micro/tools/cmsis/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s8.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_fast_s16.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_s8.c arm_convolve_s16.c arm_convolve_wrapper_s8.c arm_convolve_wrapper_s16.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_s16.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_kernel_s8_s16_reordered.c arm_nn_mat_mult_s8.c
    ./Packages/tflite_micro/tensorflow/lite/micro/tools/cmsis/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_s8.c arm_fully_connected_s16.c
    ./Packages/tflite_micro/tensorflow/lite/micro/tools/cmsis/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mul_kernel_s16.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mult_q7.c arm_nn_mult_q15.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
    ./Packages/tflite_micro/tensorflow/lite/micro/tools/cmsis/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_s8.c arm_avgpool_s16.c arm_max_pool_s8.c arm_max_pool_s16.c arm_pool_q7_HWC.c
    ./Packages/tflite_micro/tensorflow/lite/micro/tools/cmsis/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
    ./Packages/tflite_micro/tensorflow/lite/micro/tools/cmsis/CMSIS/NN/Source/SoftmaxFunctions/: arm_nn_softmax_common_s8.c arm_softmax_q7.c arm_softmax_q15.c arm_softmax_s8.c arm_softmax_s8_s16.c arm_softmax_s16.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
    ./Packages/tflite_micro/tensorflow/lite/micro/tools/cmsis/CMSIS/NN/Source/SVDFunctions/: arm_svdf_s8.c arm_svdf_state_s16_s8.c
  group tensorflow/lite/c
    ./Packages/tflite_micro/tensorflow/lite/c/: common.cc
  group tensorflow/lite/core
    ./Packages/tflite_micro/tensorflow/lite/core/api/: error_reporter.cc flatbuffer_conversions.cc op_resolver.cc tensor_utils.cc
  group tensorflow/lite/schema
    ./Packages/tflite_micro/tensorflow/lite/schema/: schema_utils.cc
  group tensorflow/lite/kernels
    ./Packages/tflite_micro/tensorflow/lite/kernels/: kernel_util.cc
    ./Packages/tflite_micro/tensorflow/lite/kernels/internal/: quantization_util.cc portable_tensor_utils.cc tensor_utils.cc
  group tensorflow/lite/micro
    ./Packages/tflite_micro/tensorflow/lite/micro/: all_ops_resolver.cc debug_log.cc fake_micro_context.cc flatbuffer_utils.cc memory_helpers.cc micro_allocation_info.cc micro_allocator.cc micro_context.cc micro_graph.cc micro_interpreter.cc micro_log.cc micro_profiler.cc micro_resource_variable.cc micro_string.cc micro_time.cc micro_utils.cc mock_micro_graph.cc recording_micro_allocator.cc system_setup.cc test_helper_custom_ops.cc test_helpers.cc
  group tensorflow/lite/micro/kernels
    ./Packages/tflite_micro/tensorflow/lite/micro/kernels/: activations.cc arg_min_max.cc assign_variable.cc batch_to_space_nd.cc broadcast_args.cc broadcast_to.cc call_once.cc cast.cc ceil.cc circular_buffer.cc cumsum.cc depth_to_space.cc dequantize.cc detection_postprocess.cc detection_postprocess_flexbuffers_generated_data.cc div.cc elementwise.cc elu.cc ethosu.cc exp.cc expand_dims.cc fill.cc floor.cc floor_div.cc floor_mod.cc gather.cc gather_nd.cc hard_swish.cc if.cc kernel_runner.cc kernel_util.cc l2_pool_2d.cc l2norm.cc leaky_relu.cc log_softmax.cc logical.cc logistic.cc lstm_eval.cc maximum_minimum.cc micro_tensor_utils.cc mirror_pad.cc neg.cc pack.cc pad.cc prelu.cc quantize.cc read_variable.cc reduce.cc reshape.cc resize_bilinear.cc resize_nearest_neighbor.cc round.cc select.cc shape.cc slice.cc space_to_batch_nd.cc space_to_depth.cc split.cc split_v.cc squared_difference.cc squeeze.cc strided_slice.cc sub.cc tanh.cc transpose.cc unidirectional_sequence_lstm.cc unidirectional_sequence_lstm_test_config.cc unpack.cc var_handle.cc while.cc zeros_like.cc activations_common.cc add_common.cc circular_buffer_common.cc conv_common.cc depthwise_conv_common.cc dequantize_common.cc fully_connected_common.cc hard_swish_common.cc leaky_relu_common.cc logical_common.cc logistic_common.cc pooling_common.cc quantize_common.cc reduce_common.cc softmax_common.cc sub_common.cc svdf_common.cc
  group tensorflow/lite/micro/kernels/cmsis
    ./Packages/tflite_micro/tensorflow/lite/micro/kernels/cmsis_nn/: add.cc conv.cc depthwise_conv.cc fully_connected.cc mul.cc pooling.cc softmax.cc svdf.cc
  group tensorflow/lite/micro/memory
    ./Packages/tflite_micro/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc linear_memory_planner.cc non_persistent_buffer_planner_shim.cc
  group tensorflow/lite/micro/tflite_bridge
    ./Packages/tflite_micro/tensorflow/lite/micro/tflite_bridge/: op_resolver_bridge.cc flatbuffer_conversions_bridge.cc micro_error_reporter.cc
  group tensorflow/lite/micro/arena_allocator
    ./Packages/tflite_micro/tensorflow/lite/micro/arena_allocator/: non_persistent_arena_buffer_allocator.cc persistent_arena_buffer_allocator.cc recording_single_arena_buffer_allocator.cc single_arena_buffer_allocator.cc
  group gesture_detector
    ./Packages/tflite_micro/tensorflow/lite/micro/examples/gesture_detector/: gesture_detect_model_data.cc main_functions.cc
  group tensorflow/lite/kernels/internel/reference
    ./Packages/tflite_micro/tensorflow/lite/kernels/internal/reference/: portable_tensor_utils.cc
